# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab5
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./StdPeriph;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source;.\STM32\inc;.\STM32\src;.\STM32
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./: main.c
  group StdPeriph
    ./STM32/: stm32f4xx_conf.h
    ./STM32/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_adc.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 2.4.2
